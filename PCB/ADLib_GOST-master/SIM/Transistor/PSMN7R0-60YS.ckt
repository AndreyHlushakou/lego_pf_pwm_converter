*****************************************************************
* NXP PSMN7R0_60YS
*
* Polarity N-Channel
* Ratings 60V/7.00E-03OHMS/15A
*
* Date Created Mon Jun  7 13:20:53 2010
*
*****************************************************************
* Model Generated by Transim Technology
*           Copyright(c) 2004
*         All Rights Reserved
*    UNPUBLISHED LICENSED SOFTWARE
*           www.transim.com
*
* Contains Proprietary Information Which
* is The Property of Transim or it's licensees.
*
* Commercial Use or Resale Restricted by
* Transim License Agreement.
*
*****************************************************************

.SUBCKT PSMN7R0_60YS DRAIN GATE SOURCE

LD DRAIN 5 5e-12
RLD2 DRAIN 5 0.01256636
RLD1 5 4 1e-06
LG GATE 1 5.43147180559945e-10
RLG GATE 1 1.36507660078025
LS SOURCE 8 9e-10
RLS2 SOURCE 8 2.2619448
RLS1 8 7 0.00035

RDS 7 4 1500000000 TC=-0.05

RS 6 7 0.0001

RD 3 4 0.00319624206865272 TC=0.00433422706438303,1.93823904966475e-05
RBD 9 4 0.00050503659272982 TC=0.00433422706438303,1.93823904966475e-05
DBD 7 9 DBD

M1 3 2 6 6 MINT

RGS 2 6 10000000000
CGS 2 6 2.01122222222222e-09
RG 1 2 0.647840585732129

* CGD
C11    11   12   1E-12
V11    11   0   0Vdc
G11    3 2 VALUE { V(13, 0)*I(V11) }
E11    12   0  3 2  1
E12    13   0  TABLE {V(12)}
+ -20	2434
+ -10	2425
+ -5	2399
+ -2	1737
+ -1	1297
+ -0.5	996
+ -0.2	813
+ -0.1	768
+ 0	736.5
+ 0.1	678
+ 0.2	633
+ 0.5	600
+ 1	473
+ 2	374
+ 5	287
+ 10	254
+ 20	222
+ 25	211
+ 30	202.4
+ 60  150

.MODEL MINT NMOS(Vto=3.5 Kp=1.4124e+02 Nfs=550000000000 eta=1000
+ Level=3 L=1e-4 W=1e-4 Gamma=0 Phi=0.6   Is=1e-24
+ Js=0 Pb=0.8  Cj=0 Cjsw=0 Cgso=0 Cgdo=0 Cgbo=0
+ Tox=1e-07 Xj=0
+ U0=600    Vmax=1000)

.MODEL DBD D(Bv=67.20 Ibv=2.50E-04 Rs=1E-6 Is=2.08278499460009e-12
+ N=1 M=0.58 VJ=0.5 Fc=0.5 Cjo=1.955e-09 Tt=4.185e-08)

.ENDS
