*****************************************************************
* NXP PSMN1R7-60BS
*
* Polarity N-Channel
* Ratings 60V/2.000000E-003OHMS/120A
*
* Date Created Mon Oct 24 06:25:02 2011
*
*****************************************************************
* Model Generated by Transim Technology
*           Copyright(c) 2004
*         All Rights Reserved
*    UNPUBLISHED LICENSED SOFTWARE
*           www.transim.com
*
* Contains Proprietary Information Which
* is The Property of Transim or it's licensees.
*
* Commercial Use or Resale Restricted by
* Transim License Agreement.
*
*****************************************************************

.SUBCKT PSMN1R7-60BS DRAIN GATE SOURCE

LD DRAIN 5 5e-12
RLD2 DRAIN 5 0.0125663706143592
RLD1 5 4 1e-06
LG GATE 1 7.81292696075128e-10
RLG GATE 1 1.96360271543439
LS SOURCE 8 3.28320266346739e-09
RLS2 SOURCE 8 8.25158829423648
RLS1 8 7 0.000767481695870964

RDS 7 4 60000000 TC=-0.05

RS 6 7 0.0001

RD 3 4 0.00048 TC=0.0211825285628363,-5.4400328384773E-06
RBD 9 4 0.000553080974773068 TC=0.0211825285628363,-5.4400328384773E-06
DBD 7 9 DBD

M1 3 2 6 6 MINT

RGS 2 6 200000000
CGS 2 6 7.75594426055502e-09
RG 1 2 0.876633761817533

* CGD
C11    11   12   1E-12
V11    11   0   0Vdc
G11    3 2 VALUE { V(13, 0)*I(V11) }
E11    12   0  3 2  1
E12    13   0  TABLE {V(12)}
+ -1	4777
+ -0.5	3566
+ -0.2	2805
+ -0.1	2545
+ 0	2409.5
+ 0.1	2202
+ 0.2	2040
+ 0.5	1794
+ 1	1563
+ 2	1262
+ 5	948
+ 10	814
+ 12	783
+ 20	699
+ 25	663
+ 30	635

.MODEL MINT NMOS(Vto=3.840 Kp=4.500e+002 Nfs=680000000000 Eta=1000
+ Level=3 L=1e-4 W=1e-4 Gamma=0 Phi=0.6 Is=1e-24
+ Js=0 Pb=0.8 Cj=0 Cjsw=0 Cgso=0 Cgdo=0 Cgbo=0
+ Tox=1e-07 Xj=0
+ U0=600 Vmax=1000)

.MODEL DBD D(Bv=65 Ibv=2.500000E-004 Rs=1E-6 Is=7.95463053908584e-12
+ N=1 M=0.54 VJ=0.52 Fc=0.5 Cjo=5.351e-09 Tt=4.9e-08)

.ENDS
